# Keil uVision project serial.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: serial +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c includes.h
    ./delay/: delay.c
    ./serial/: serial.c
