# Keil uVision project DU-LI-KEY.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC-STC12
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: DU-LI-KEY +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ./delay/: delay.c
    ./smg/: smgdisplay.c
    ./Key/: Key1.c
