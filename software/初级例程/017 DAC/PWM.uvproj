# Keil uVision project PWM.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC12C5A60S2 STC-STC12
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: PWM +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: config.h includes.h main.c
    ./delay/: delay.c delay.h
    ./PWM/: PWM.c PWM.h
