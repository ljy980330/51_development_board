# Keil uVision project temper_oled.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C51RC STC-STC89
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0xFFF) CLOCK(45000000) MODP2
  output: temper_oled +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ./code_tab/: code_tab.c
    ./display/: display.c
    ./function/: function.c
    ./i2c/: i2c.c
    ./delay/: delay.c
    ./OLED_Init/: OLED_Init.c
    ./drive/: drive.c
