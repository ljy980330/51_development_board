/*********************************************************************************************************
*名称：delay.c
*功能：延时所用到的函数
创建时间：2019/7/14
修改时间：2019/XX/XX
作者：XXX
**********************************************************************************************************/

#include "delay.h"
						 
#include "../config.h"
#include "../code_tab/code_tab.h"
#include "../function/function.h"


/*******************************************************************************
* 函 数 名         : Delay_30us
* 函数功能		   : 延时函数，30us的延时
*******************************************************************************/

void Delay_30us()//@12.000MHz
{
	uchar i;
	i=87;
	while(--i);
}

/*******************************************************************************
* 函 数 名         : Delay_20ms
* 函数功能		   : 延时函数，20Ms的延时
*******************************************************************************/

void Delay_20ms()//@12.000MHz
{
	uchar i,j,k;
	i=1;
	j=234;
	k=113;
	do
	{
		do
		{
			while(--k);
		}
	  while(--j);
	}while(--i);
}

/*******************************************************************************
* 函 数 名         : Delay_1s
* 函数功能		   : 延时函数，1s的延时
*******************************************************************************/

void Delay_1s()//@12.000MHz
{
	uchar i,j,k;
	i=46;
	j=153;
	k=245;
	do
	{
		do
		{
			while(--k);
		}
	  while(--j);
	}while(--i);
}

/*******************************************************************************
* 函 数 名         : Delay_ms
* 函数功能		   : 延时函数，1Ms的延时
*******************************************************************************/
void Delay_ms(uint z)
{
	uint x,y;

	for(x=z;x>0;x--)

		for(y=110;y>0;y--);
}

/*******************************************************************************
* 函 数 名         : nop
* 函数功能		   : 延时函数，当晶振为12HZ，延时2us
*******************************************************************************/

void Delay_nop(uint counter)
{
	int i;
	
	for(i=0; i<counter; i++)
		_nop_();
}									   
/*******************************************************************************
* 函 数 名         : nop
* 函数功能		   : 延时函数，当晶振为12HZ，延时2us
*******************************************************************************/

void nop()
{
	_nop_();
	_nop_();
}