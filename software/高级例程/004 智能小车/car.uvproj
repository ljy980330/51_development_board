# Keil uVision project car.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: car +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: main.c
    ./delay/: delay.c
    ./color/: color.c
    ./flame/: flame.c
    ./pwm/: pwm.c
    ./track/: track.c
    ./voice/: voice.c
