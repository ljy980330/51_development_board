# Keil uVision project temperature_drive.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C51RC STC-STC89
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0xFFF) CLOCK(45000000) MODP2
  output: temperature_drive +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ./delay/: delay.c
    ./data_read/: data_read.c
