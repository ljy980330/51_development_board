# Keil uVision project ds3231_rtc_clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: ds3231_rtc_clock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../src/: main.c
    ../src/ds3231/: rtc.c
    ../src/i2c/: i2c.c
    ../src/delay/: delay.c
    ../src/printf_init/: printf_init.c
